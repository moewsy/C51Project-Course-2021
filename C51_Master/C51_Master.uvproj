# Keil uVision project C51_Master.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: C51_Master +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\inc
  group Source Group 1
    ./: STARTUP.A51
  group src
    ./: main.c
    ../src/: keyboard.c MAX5822.c LCD.c UART.c
  group inc
    ./: main.h
    ../inc/: keyboard.h MAX5822.h LCD.h char_lib.h UART.h
