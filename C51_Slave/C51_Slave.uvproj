# Keil uVision project C51_Slave.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: C51_Slave +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\inc
  group Source Group 1
    ./: STARTUP.A51
  group src
    ./: main.c
    ../src/: ADC0832.c
  group inc
    ./: main.h
    ../inc/: ADC0832.h
